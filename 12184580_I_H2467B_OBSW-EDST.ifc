Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-27T09:23:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 27 09:23:35 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\8b90f6e6-c51f-496d-b39c-d827956e0b65\3d27035a-a365-4c3c-9da1-a0c3d73e8b1c\ifc * Database version: 5507 * Database creation date: Fri Jan 27 09:23:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 27 09:23:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 27 09:23:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12184580_I_H2467B_OBSW-EDST:22246704_I_12184580_H2467B_OBSW-EDST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 22246704_I_12184580_H2467B_OBSW-EDST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 22246704_I_12184580_H2467B_OBSW-EDST
Type - Pset_ProvisionForVoid - Depth: 568 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Alusilver, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 596 mm

# IfcDistributionPort, Port_353918
Description: Flow; FlowDirection: SOURCEANDSINK
